## boards/shields/rhymestone_right/Kconfig.defconfig
```kconfig
config ZMK_KEYBOARD_NAME
    default "rhymestone_right"  # or "rhymestone_right"
```
